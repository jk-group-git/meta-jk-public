SRC_URI = " \
git://github.com/jthornber/thin-provisioning-tools.git;protocol=https;branch=main \
file://0001-do-not-strip-pdata_tools-at-do_install.patch \
"

SRC_URI[sha256sum] = "ed1bfce7e246073777024465cbe130af77276d51e9fc11c35690e7285d6acb0e"
