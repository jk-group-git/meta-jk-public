SRC_URI = " \
git://github.com/storaged-project/libbytesize;branch=main;protocol=https \
file://0001-remove-python2-support.patch \
"
